# Keil uVision project Template.uvprojx, settings and files
target MASTER (6120000::V6.12::.\ARMCLANG)
  device: M253LE3AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.18
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: MASTER +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c define: ENABLE_MODBUS_MASTER
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\StdDriver\inc;..\..\..\Library\Device\Nuvoton\M253\Include;..\..\Template;..\modbus\include;..\modbus\rtu;..\modbus\ascii;..\port
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M253.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M253/Source/: system_M253.c
    ../../../Library/Device/Nuvoton/M253/Source/ARM/: startup_M253.s
  group Library
    ../../../Library/StdDriver/src/: retarget.c uart.c sys.c clk.c timer.c gpio.c
  group User
    ../: main.c misc_config.c
  group FreeModbus
    ../port/: port.c
    ../modbus/tcp/: mbtcp.c
    ../modbus/rtu/: mbcrc.c
    ../modbus/functions/: mbutils.c mbfuncother.c mbfuncdiag.c
    ../modbus/ascii/: mbascii.c
  group FreeModbusSlave
    ../modbus/: mb.c
    ../modbus/functions/: mbfunccoils.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c
    ../modbus/rtu/: mbrtu.c
    ../port/: portserial.c portevent.c porttimer.c
    ../: mb_slave.c
  group FreeModbuMaster
    ../modbus/: mb_m.c
    ../modbus/rtu/: mbrtu_m.c
    ../modbus/functions/: mbfuncinput_m.c mbfuncholding_m.c mbfuncdisc_m.c mbfunccoils_m.c
    ../port/: portevent_m.c portserial_m.c porttimer_m.c
    ../: mb_master.c
target SLAVE (6120000::V6.12::.\ARMCLANG)
  device: M253LE3AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.18
  cpu: as above
  output: SLAVE +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c define: ENABLE_MODBUS_SLAVE
  c include: as above
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: as above
software components: CMSIS:CORE 5.2.0
